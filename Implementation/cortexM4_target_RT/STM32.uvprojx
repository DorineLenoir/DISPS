# Keil uVision project STM32.uvprojx, settings and files
target NucleoF446xx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TDx
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./: main.c SysClock.c SysTick.c
    ../src/: IIR_filter.c
  group StartUp
    ./: startup_stm32f446xx.s
  group Inc
    ./: main.h PinNames.h stm32f4xx_gpio_AF.h SysClock.h SysTick.h stm32f446xx.h
  group DoxyGen
    ./: STM32.doxy
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0
